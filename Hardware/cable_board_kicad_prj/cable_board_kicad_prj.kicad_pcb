# Repository Residuum22/EDFAController (continued)

## KiCad design Hardware/CableBoard/cable_board_kicad_prj/cable_board_kicad_prj.kicad_pcb

Parts:
J1, J3, J4, J6: Conn_02x08_Odd_Even; IDC-Header_2x08_P2.54mm_Latch_Vertical
J2, J5: Conn_02x30_Counter_Clockwise; IDC-Header_2x30_P2.54mm_Latch_Vertical

Connections:
/LASER1_GND: J2.50, J3.9
/LASER1_TEMP: J2.54, J3.11
/LASER2_GND: J2.28, J3.10
/LASER2_TEMP: J2.32, J3.12
/LASER3_GND: J2.8, J4.9
/LASER3_TEMP: J2.12, J4.11
/LASER4_GND: J4.10, J5.57
/LASER4_TEMP: J4.12, J5.53
/LASER5_GND: J5.31, J6.9
/LASER5_TEMP: J5.27, J6.11
/LASER6_GND: J5.21, J6.10
/LASER6_TEMP: J5.17, J6.12
/LASER12_PWR: J2.27, J2.31, J2.49, J2.53, J3.15
/LASER34_PWR: J2.7, J2.11, J4.15, J5.54, J5.58
/LASER56_PWR: J5.18, J5.22, J5.28, J5.32, J6.15
/MONITORD1: J2.51, J3.13
/MONITORD2: J2.29, J3.14
/MONITORD3: J2.9, J4.13
/MONITORD4: J4.14, J5.56
/MONITORD5: J5.30, J6.13
/MONITORD6: J5.20, J6.14
/PELTIER1+: J2.55, J2.56, J3.1, J3.3
/PELTIER1-: J2.57, J2.58, J3.5, J3.7
/PELTIER2+: J2.33, J2.34, J3.2, J3.4
/PELTIER2-: J2.35, J2.36, J3.6, J3.8
/PELTIER3+: J2.13, J2.14, J4.1, J4.3
/PELTIER3-: J2.15, J2.16, J4.5, J4.7
/PELTIER4+: J4.2, J4.4, J5.51, J5.52
/PELTIER4-: J4.6, J4.8, J5.49, J5.50
/PELTIER5+: J5.25, J5.26, J6.1, J6.3
/PELTIER5-: J5.23, J5.24, J6.5, J6.7
/PELTIER6+: J5.15, J5.16, J6.2, J6.4
/PELTIER6-: J5.13, J5.14, J6.6, J6.8
/VOA_POT_MEAS: J1.11, J2.46
/VOA_POT_PWR: J1.12, J2.42
/VOA_STEP_A+: J1.3, J2.45
/VOA_STEP_A-: J1.7, J2.43
/VOA_STEP_B+: J1.4, J2.41
/VOA_STEP_B-: J1.8, J2.39
GND: J1.1, J1.2, J1.5, J1.6, J1.9, J1.10, J1.13, J1.14, J1.15, J1.16, J2.5, J2.6, J2.10, J2.30, J2.40, J2.44, J2.52, J3.16, J4.16, J5.11, J5.19, J5.29, J5.40, J5.43, J5.44, J5.55, J6.16

Notes on the sheet:
Connector 1 (Table 2D.1)
Connector 2 (Table 2D.2)
Pin 59 (ID[7]) left NC, so the VOA default mode is full step mode.

Board: 2 copper layers, 100.0 x 70.0 mm, 6 parts (0 on the bottom side), 40 nets.

## Commit log

2022-04-24 VOA controller schematics added
2022-05-04 VOA pcb + better schematics
2022-05-05 Add VOA board teardrops and bigger power track vias
2022-05-05 Better power trace
2022-05-05 New develop branch with voa and laser controller save
2022-05-05 Updated gitignore
2022-05-05 VOA controller waiting for revision
2022-05-05 Laser module schematic ready to revision
2022-05-06 Laser controller Ready to rev
2022-05-06 VOA PCB ribbon con. changed and laser PCB teardrops added
2022-05-06 Something changed
2022-09-12 Add necessary documentation and update cable board NC and GND pins according to the documentation
2022-09-12 Update cable board with VOA connections and add some text to the VOA board
2022-09-13 Add copper fill keepout area under the esp32 for easier soldering
2022-09-14 Laser module clean up
2022-09-14 Cable board sign all EDFA connector pin & PDF delete markers & cleanup
2022-10-04 Add LTSpice simulation, esp32 datasheet to the project and add kicad script for bom generation and add protection for voa module with finished schematics
2022-10-07 VOA controller ready to review
2022-10-08 Add simulations for laser module
2022-10-08 Fix laser controll circuit and add lowpass to the end of monitor diode amplifier.
2022-10-09 Ready to review of laser_module
2022-10-09 Cable board ready to review
2022-10-09 Some fix changes
2022-10-17 Update hardware
2023-02-20 Add test html for prototyping
2023-02-20 Update readme, gitignore, requirements and write simple backend
2023-02-26 Add websocket handling with tests and rename src to app
2023-03-07 Project structure change
2023-03-09 Fix images path and add voa_position control on the page
2023-03-09 Add minimalist response for backend
2023-03-10 Minimize folder structure of the project
2023-03-10 Add autoreload, update readme, gitignore, fix images, add getters into backend
2023-03-10 Add laser events script (currently just for laser1)
2023-03-10 Finalize project structure :)
2023-03-10 Add bootstrap through npm, add missing ids
2023-03-10 Add enabling and disabling modules
2023-03-10 Refactor basemodels according to the docs, making a general post req in js.
2023-03-11 Add websocket processing for laser_module and voa_module, add websocket test, change enable disable api for sorten url
    TODO: Write test to run test in the same time, and wirte javascript for automatically get data from backend and show in the frontend
2023-03-11 Move test send_module_data to mm_edfa_boards because it will be a module simulation. Remove docs becuse it is unused. Update gitignore with vscode
2023-03-11 Add websocket handling for incoming data + handling setting data, update naming in frontend
2023-03-11 NOT_TESTED: Add websocket handling for future frontend use.
2023-03-12 Add laser module generator with templates, fix backend to stay active if no module is connected, modify laser events javascript better naming
2023-03-12 WIP: Add laser module js (currently not working sync commit)
2023-03-14 Add laser module websocket processing into the frontend
2023-04-19 Add simulation and fix laser controll circuit
2023-04-19 Simulation and sch modification
2023-04-19 Refactor project structure
2023-04-19 Move project folder up in hardware.
2023-04-19 Add boms to project
2023-04-19 Add voa hw test in arduino framework
2023-04-19 Change DC connector pad from oval to circle
    Add 3v3 connector for external power supply
2023-04-19 Remove log files and update readme
2023-04-19 Init voa_firmware
2023-04-19 Modify laser board schematics according to the prototype issues.
    Add the monitor diode part to the PCB
    Update revision and finish PCBs
2023-04-19 Gitingore update with firmware
2023-04-19 (FIX) Add voltage divider to 5V potentiometer from voa
2023-04-19 Change laser controller circuit add resistor to feedback pin of the op amp
    Add SOT-223 new fet to the board.
2023-04-19 Add simulated laser modules
2023-04-19 Remove firmware from develop
2023-04-19 Remove zxbm5210 driver and readme files. Add lwjson repo to the project for future use.
2023-04-19 Modify main.c and init zxbm5210 drivers
2023-04-19 VOA firmware with MQTT and WIFI and MCPWM
2023-04-19 Hardware tmp laser controller design
2023-04-19 Modify disconnect indicator and rename wifi disconnet.
2023-04-19 Add bang-bang controller for the VOA control.
2023-04-20 VOA hw: Rev 3.0 & Change ADC instance.
    Hardware change, because the ADC2 used by WiFi.
2023-05-08 Add EDFA blokk diagram as a html to the project
2023-05-08 Change content of the edfa.html
2023-05-15 Change voa attenuation set topic in the software (sync with webpage)
2023-05-15 Remove websocket, add mqtt, change bootstrap localmodule to web, better indentation.
2023-05-21 Add help to the webpage.
2023-05-21 Update frontend (html) according to the new system design.
2023-05-21 Fix VOA communication in frontend and backend.
2023-05-21 Fix desired temperature according to the new system design and send it through mqtt
2023-05-21 Add emergency exit option in front end backend
2023-06-10 Refactor main.c
    Move lots of function into the correct place.
2023-06-27 Change reserve voltage protection simulation to better demonstration.
2023-06-27 VOA hw: Change version number and prepare for finilazing.
2023-06-27 Laser hw: Update laser revision number, add potentiometer to measurement diodes, connect all analog siganal to ADC1
2023-06-27 Cable brd: Move to kicad 7.0, elimanate wrong connection with voa.
2023-07-27 [VOA Software] Add end-position mapping and emergency stop of voa is stucked.
2023-07-27 [VOA Software] Add comments to the VOA code and re-structure the code.
2023-08-20 Add json parsing and laser module reports working again.
2023-09-19 [VOA Software] Fix code and refactor
2023-09-28 [VOA Software] Add mqtt adjustable epsilon value settings.
2023-10-06 [VOA Software] Fix indicator connecting and add error basic error handling.
2023-10-06 [Laser Software] Initialize laser software project (copy-voa project)
2023-10-06 Make web backend compatible with python3.9
2023-10-06 [Laser Software] Port to 5.1.1 and develop the basics of the laser application
2023-10-08 [Laser Software] Add peltier bang-bang controller, code butify and update README
2023-10-08 [Laser Software] Add exponential and linear interpolated temperature measuring of the Peltier
2023-10-10 [Laser Software] Add laser current control and change mqtt message to wait for laser_current not for monitor diode current
2023-10-12 Change monitor diode to laser diode
2023-10-16 [VOA Software] Fix stepper motor control
2023-10-21 [Laser Software]: WIP enable button is not working
2023-10-21 [VOA Software]: Create working software with the right frequency
2023-10-22 [VOA Software]: Ready for the final testing of the VOA software.
2023-10-29 [Laser Software]: Add PID controller for Peltier, refactor code, change uint8_t laser enable
2023-10-30 [Laser Software]: Write MD to serial
2023-11-03 [Cable Hardware]: Fix short in the panel
2023-11-03 [Laser Hardware]: Fix temp reading issue due to hardware
2023-11-03 [Common Hardware]: Add issues md under issues folder.
2023-12-10 [Laser Firmware] Add current conversion by the laser current
2023-12-10 [Laser Firmware] Enable debug level logging
2023-12-10 [Laser Firmware] Calibrate peltier and laser control pid
2023-12-10 [Laser Firmware] Add enable for the laser current adjustment
2023-12-10 [Laser Firmware] Adjust PID values by the peltier and the laser current
2023-12-10 [Laser Software] Adjust code in the laboratory
2023-12-10 [Laser Software] Add laser pid controller
2023-12-10 Remove OPTIONS requests and simplify index.html
2023-12-10 Finalize webpage
2023-12-11 [Laser Firmware] Add enable for lasers, implement report initial untested logic, remove bang-bang controller from peltier
2024-01-06 [Laser Hardware]: Fix PCB with the new laser current source design.
2024-01-06 [VOA Hardware]: Create warning excludes which is not relevant
2024-01-06 [Cable Hardware] Change monitor diodes connection.
2024-01-28 Revert "[Cable Hardware] Change monitor diodes connection."
    This reverts commit 7c23bd38936932b363231632e559990db4feac3f.
2024-01-28 [Cable Hardware] Add solder connector for the monitor diode cathode.
2024-02-03 [TestSoftware]: EDFA Laser board cJSON test
2024-05-25 [Firmware]: Add unit test framwork and mock generator
2024-06-02 [Firmware]: Remove info logging from PID controller
2024-06-02 [Firmware]: Fix LaserModule cJSON stack overflow and increase time between report generations
2024-06-02 [Firmware]: Add KConfig generated header to vscode
2024-06-02 [Firmware]: Add debug configurations and increase stack size for freertos
2024-06-02 Show current settings after reload of the page
2024-10-08 Update host url
2024-10-08 Change bootstrap path to the local node module
2024-10-08 Port Website to Raspberry Pi
