# Repository Residuum22/EDFAController

File README.md:

# EDFAController
This project was created for my MSc thesis This project mixes the mm_edfa_boards and mm_edfa_web projects.

## KiCad design Hardware/cable_board_kicad_prj/cable_board_kicad_prj.kicad_pcb

Parts:
C1, C2, C5: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4, C6: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1, J3, J4, J6: Conn_02x08_Odd_Even; IDC-Header_2x08_P2.54mm_Latch_Vertical
J2, J5: Conn_02x30_Counter_Clockwise; IDC-Header_2x30_P2.54mm_Latch_Vertical
JP1, JP2, JP3, JP4, JP5, JP6: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
U1, U2, U3: FH1117SXX-SE; SOT-223-3_TabPin2

Connections:
/LASER1_GND: J2.36, J3.9
/LASER1_TEMP: J2.34, J3.11
/LASER2_GND: J2.47, J3.10
/LASER2_TEMP: J2.45, J3.12
/LASER3_GND: J2.57, J4.9
/LASER3_TEMP: J2.55, J4.11
/LASER4_GND: J4.10, J5.29
/LASER4_TEMP: J4.12, J5.27
/LASER5_GND: J5.16, J6.9
/LASER5_TEMP: J5.14, J6.11
/LASER6_GND: J5.11, J6.10
/LASER6_TEMP: J5.9, J6.12
/LASER12_PWR: C1.1, J2.14, J2.16, J2.25, J2.27, J3.15, U1.3 (VI)
/LASER34_PWR: C2.1, J2.4, J2.6, J4.15, J5.32, J5.34, U2.3 (VI)
/LASER56_PWR: C5.1, J5.45, J5.47, J5.50, J5.52, J6.15, U3.3 (VI)
/MONITORD1: J2.26, J3.13
/MONITORD2: J2.15, J3.14
/MONITORD3: J2.5, J4.13
/MONITORD4: J4.14, J5.33
/MONITORD5: J5.46, J6.13
/MONITORD6: J5.51, J6.14
/MONITORD12_3V3: C3.1, JP1.1 (A), JP2.1 (A), U1.2 (VO)
/MONITORD34_3V3: C4.1, JP3.1 (A), JP6.1 (A), U2.2 (VO)
/MONITORD56_3V3: C6.1, JP4.1 (A), JP5.1 (A), U3.2 (VO)
/PELTIER1+: J2.28, J2.33, J3.1, J3.3
/PELTIER1-: J2.29, J2.32, J3.5, J3.7
/PELTIER2+: J2.17, J2.44, J3.2, J3.4
/PELTIER2-: J2.18, J2.43, J3.6, J3.8
/PELTIER3+: J2.7, J2.54, J4.1, J4.3
/PELTIER3-: J2.8, J2.53, J4.5, J4.7
/PELTIER4+: J4.2, J4.4, J5.26, J5.35
/PELTIER4-: J4.6, J4.8, J5.25, J5.36
/PELTIER5+: J5.13, J5.48, J6.1, J6.3
/PELTIER5-: J5.12, J5.49, J6.5, J6.7
/PELTIER6+: J5.8, J5.53, J6.2, J6.4
/PELTIER6-: J5.7, J5.54, J6.6, J6.8
/VOA_POT_MEAS: J1.12, J2.38
/VOA_POT_PWR: J1.11, J2.40
/VOA_STEP_A+: J1.3, J2.23
/VOA_STEP_A-: J1.7, J2.22
/VOA_STEP_B+: J1.4, J2.21
/VOA_STEP_B-: J1.8, J2.20
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.1, J1.2, J1.5, J1.6, J1.9, J1.10, J1.13, J1.14, J1.15, J1.16, J2.39, J2.41, J3.16, J4.16, J6.16, JP1.3 (B), JP2.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), JP6.3 (B), U1.1 (GND), U2.1 (GND), U3.1 (GND)
unnamed: J2.35, JP1.2 (C)
unnamed: J2.46, JP2.2 (C)
unnamed: J2.56, JP3.2 (C)
unnamed: J5.10, JP4.2 (C)
unnamed: J5.15, JP5.2 (C)
unnamed: J5.28, JP6.2 (C)

Notes on the sheet:
Connector 1 (Table 2D.1)
Connector 2 (Table 2D.2)
Pin 59 (ID[7]) left NC, so the VOA default mode is full step mode.

Board: 2 copper layers, 100.0 x 70.0 mm, 21 parts (15 on the bottom side), 49 nets.

## KiCad design Hardware/voa_controller_kicad_prj/voa_controller_kicad_prj.kicad_pcb

Parts:
C1: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C7, C8, C9, C11, C12, C13, C14: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10: 680n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED_Dual_AAK; SOT-23
IC1: ESP32-WROVER-IE; ESP32WROVERIE; Manufacturer_Part_Number ESP32-WROVER-IE; Mouser 356-ESP32WVIE23264UC
J1: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J2: Barrel_Jack_Switch_Pin3Ring; BarrelJack_Horizontal
J3: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical_SMD
J4: Conn_02x08_Odd_Even; IDC-Header_2x08_P2.54mm_Latch_Vertical
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
R1, R3, R4, R9, R10: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 68; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 56; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm_H7.3mm
TP1: TestPoint; PinHeader_1x01_P2.54mm_Vertical
U2, U3: ZXBM5210-S; SOIC-8_3.9x4.9mm_P1.27mm; Mouser 621-ZXBM5210-S-13

Connections:
+3V3: C1.1, C3.1, C7.1, IC1.2 (3V3), J1.1, J3.1 (VTref), R1.2; also elsewhere on the board
+5V: C8.1, C9.1, J4.11, R3.1, R4.1, U2.2 (VM), U2.3 (VDD), U3.2 (VM), U3.3 (VDD); also elsewhere on the board
/BOOT: IC1.25 (IO0), JP1.2 (B)
/ESP32_EN: C2.2, IC1.3 (EN), J3.10 (~RESET), R1.1, SW1.2
/ESP32_JTAG_TCK: IC1.16 (IO13), J3.4 (SWDCLK/TCK)
/ESP32_JTAG_TDI: IC1.14 (IO12), J3.8 (NC/TDI)
/ESP32_JTAG_TDO: IC1.23 (IO15), J3.6 (SWO/TDO)
/ESP32_JTAG_TMS: IC1.13 (IO14), J3.2 (SWDIO/TMS)
/LED_GREEN: IC1.29 (IO5), R6.2
/LED_RED: IC1.30 (IO18), R5.2
/MOTOR_FWD_A: IC1.8 (IO32), U2.4 (FWD)
/MOTOR_FWD_B: IC1.10 (IO25), U3.4 (FWD)
/MOTOR_REV_A: IC1.9 (IO33), U2.5 (REV)
/MOTOR_REV_B: IC1.11 (IO26), U3.5 (REV)
/Motor_A+: C13.1, J4.3, U2.1 (OUT1)
/Motor_A-: C11.1, J4.7, U2.7 (OUT2)
/Motor_B+: C14.1, J4.4, U3.1 (OUT1)
/Motor_B-: C12.1, J4.8, U3.7 (OUT2)
/Power Source and Protection/PWR_IN: J2.1; also elsewhere on the board
/SERIAL_RX: IC1.34 (RXD0), J1.2
/SERIAL_TX: IC1.35 (TXD0), J1.3
/VOA_POT: C10.1, J4.12, R9.1
/VOA_POT_DIV: IC1.4 (SENSOR_VP), R9.2, R10.1
GND: C1.2, C2.1, C3.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D1.3 (K), IC1.1 (GND_1), IC1.15 (GND_2), IC1.38 (GND_3), IC1.39 (GND_4), IC1.40 (GND_5), IC1.41 (GND_6), IC1.42 (GND_7), IC1.43 (GND_8), IC1.44 (GND_9), IC1.45 (GND_10), IC1.46 (GND_11), IC1.47 (GND_12), J1.4, J2.2, J2.3, J3.3 (GND), J3.5 (GND), J3.9 (GNDDetect), J4.1, J4.2, J4.5, J4.6, J4.9, J4.10, J4.13, J4.14, J4.15, J4.16, JP1.1 (A), R10.2, SW1.1, TP1.1, U2.8 (GND), U3.8 (GND); also elsewhere on the board
unnamed: D1.1 (A1), R5.1
unnamed: D1.2 (A2), R6.1
unnamed: R3.2, U2.6 (VREF)
unnamed: R4.2, U3.6 (VREF)

Notes on the sheet:
JTAG 10P programming header
ESP32
16P Ribbon cable output
VOA position voltage divider
VOA Motor Controller
ESP32 RS232-TTL Programming/DEBUG
ADC is precise between 0.9-2.4V so the input need to be halfed.
VOA voltage range is between 2V-4.8V
Signalling LED
Jumper on: Download from UART Jumper off: Boot from flash
Power input 5V/2A
+5V is needed for VOA positioning resistor

Parts:
C4: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2: 35V; D_SMB
D3: 3V; D_MiniMELF_Handsoldering
D4: 5V6; D_MiniMELF_Handsoldering
F1: Polyfuse 1.5A; Fuse_1812_4532Metric
Q1, Q2, Q3: Si2307CDS; SOT-23_Handsoldering
R2, R7, R8: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV1: 30V; R_1206_3216Metric
U1: IFX27001TFV33; TO-252-3_TabPin2

Connections:
+3V3: C6.1, U1.2 (Q); also elsewhere on the board
+5V: C5.1, Q3.3 (D), U1.3 (I); also elsewhere on the board
/Power Source and Protection/PWR_IN: F1.1; also elsewhere on the board
GND: C4.2, C5.2, C6.2, D2.1 (A1), D4.2 (A), R2.2, R8.2, RV1.2, U1.1 (GND); also elsewhere on the board
unnamed: C4.1, D2.2 (A2), F1.2, Q1.3 (D), RV1.1
unnamed: D3.2 (A), Q1.1 (G), R2.1
unnamed: D3.1 (K), Q1.2 (S), Q2.2 (S), Q3.2 (S), R7.1
unnamed: D4.1 (K), Q2.1 (G), R7.2
unnamed: Q2.3 (D), Q3.1 (G), R8.1

Notes on the sheet:
Overvoltage protection circuit
ESD protection
Reverse polarity protection

Board: 2 copper layers, 79.0 x 51.0 mm, 48 parts (0 on the bottom side), 33 nets.

Other parts of the board:
REF01, REF02, REF03, REF04: MountingHole_2.7mm_M2.5

## KiCad design Hardware/laser_module_kicad_prj/laser_module_kicad_prj.kicad_pcb

Board: 2 copper layers, 100.0 x 70.0 mm, 106 parts (1 on the bottom side), 74 nets.

Parts:
C1, C2, C9, C10, C23, C24: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4, C5, C6, C8, C11, C12, C14, C15, C16, C17, C18, C19, C20, C22: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C21: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C13: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED_Dual_AAK; SOT-23
D2, D5: 35V; D_SMB
D3, D6: 3V; D_MiniMELF_Handsoldering
D4, D7: 5V6; D_MiniMELF_Handsoldering
F1, F4: 3A/5A; Fuse_2920_7451Metric_Pad2.10x5.45mm_HandSolder
F2: 500mA; Fuse_2512_6332Metric_Pad1.52x3.35mm_HandSolder
F3: 1A; Fuse_2512_6332Metric_Pad1.52x3.35mm_HandSolder
IC1, IC3: LMR51420YFDDCR; SOT95P280X110-6N
IC2: ESP32-WROVER-IE; ESP32WROVERIE
J1, J2: Barrel_Jack_Switch_Pin3Ring; BarrelJack_Horizontal
J3, J4: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical
J5: Conn_02x08_Odd_Even; IDC-Header_2x08_P2.54mm_Latch_Vertical
J6: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J7: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical_SMD
JP1: locked; PinHeader_1x02_P2.54mm_Vertical
L1, L2: PCD0504
Q1, Q3, Q6, Q8: Si2333DDS; SOT-23_Handsoldering
Q2, Q7: Si2307CDS; SOT-23_Handsoldering
Q4, Q5: TSM900; SOT-223
R1, R2, R9, R12, R13, R14, R16, R20, R21, R25, R29, R31, R33, R34, R35: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4, R5, R6: 5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R36: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8, R37: 25k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10, R19, R28: 68; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 56; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R24: 3k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17, R27: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18, R26: 15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R23, R32: 1; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
RV1, RV6: 30V; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
RV2, RV4: 1k; Potentiometer_Bourns_3296X_Horizontal
SW1: SW_Push; SW_PUSH_6mm_H7.3mm
TP1: TP_GND; PinHeader_1x01_P2.54mm_Vertical
TP2, TP3, TP4, TP5: TestPoint; TestPoint_Pad_D2.5mm
U1: IFX27001TFV33; TO-252-3_TabPin2
U2, U3: ZXBM5210-S; SOIC-8_3.9x4.9mm_P1.27mm
U4, U5: LM358; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C2.1, C12.1, C13.1, C14.1, C18.1, IC2.2 (3V3), J6.1, J7.1 (VTref), R9.2, U1.2 (Q), U5.8 (V+)
+5V: C1.1, C17.1, J5.15, Q3.3 (D), U1.3 (I), U4.8 (V+)
/DC-DC Converter 1/Vin: C7.1, C21.1, IC1.3 (VIN), IC1.5 (EN), IC3.3 (VIN), IC3.5 (EN), Q8.3 (D)
/LASER1_CNTR: IC2.11 (IO26), R15.2
/LASER1_GND: F2.1, J5.9
/LASER1_MD_MEAS: C16.1, IC2.4 (SENSOR_VP), R16.1
/LASER1_TEMP: J5.11, R3.2
/LASER1_TEMP_uC: C5.1, IC2.7 (IO35), R3.1, R4.2
/LASER2_CNTR: IC2.10 (IO25), R24.2
/LASER2_GND: F3.1, J5.10
/LASER2_MD_MEAS: C19.1, IC2.5 (SENSOR_VN), R25.1
/LASER2_TEMP: J5.12, R5.2
/LASER2_TEMP_uC: C6.1, IC2.6 (IO34), R5.1, R6.2
/MONITORD1: J5.13, R18.2, U5.2 (-)
/MONITORD2: J5.14, R26.2, U5.6 (-)
/Mikrocontroller/BOOT: IC2.25 (IO0), JP1.2 (B)
/Mikrocontroller/ESP32_EN: C11.2, IC2.3 (EN), J7.10 (~RESET), R9.1, SW1.2
/Mikrocontroller/ESP32_JTAG_TCK: IC2.16 (IO13), J7.4 (SWDCLK/TCK)
/Mikrocontroller/ESP32_JTAG_TDI: IC2.14 (IO12), J7.8 (NC/TDI)
/Mikrocontroller/ESP32_JTAG_TDO: IC2.23 (IO15), J7.6 (SWO/TDO)
/Mikrocontroller/ESP32_JTAG_TMS: IC2.13 (IO14), J7.2 (SWDIO/TMS)
/Mikrocontroller/LED_GREEN: IC2.29 (IO5), R11.2
/Mikrocontroller/LED_RED: IC2.30 (IO18), R10.2
/Mikrocontroller/SERIAL_RX: IC2.34 (RXD0), J6.2
/Mikrocontroller/SERIAL_TX: IC2.35 (TXD0), J6.3
/PELT1_FWD: IC2.33 (IO21), U2.4 (FWD)
/PELT1_REV: IC2.31 (IO19), U2.5 (REV)
/PELT2_FWD: IC2.37 (IO23), U3.4 (FWD)
/PELT2_REV: IC2.36 (IO22), U3.5 (REV)
/PELTIER1+: J5.1, J5.3, U2.1 (OUT1)
/PELTIER1-: J5.5, J5.7, U2.7 (OUT2)
/PELTIER2+: J5.2, J5.4, U3.1 (OUT1)
/PELTIER2-: J5.6, J5.8, U3.7 (OUT2)
/Power Supply Protection 1/PWR_IN: F1.1, J1.1
/Power Supply Protection 2/PWR_IN: F4.1, J2.1
/Vpelt1: C3.1, C9.1, C10.1, J3.1, L1.2, R1.1, R7.1, TP2.1, U2.2 (VM), U2.3 (VDD)
/Vpelt2: C4.1, C23.1, C24.1, J4.1, L2.2, R2.1, R36.1, TP5.1, U3.2 (VM), U3.3 (VDD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C23.2, C24.2, D1.3 (K), D2.1 (A1), D4.2 (A), D5.1 (A1), D7.2 (A), IC1.1 (GND), IC2.1 (GND_1), IC2.15 (GND_2), IC2.38 (GND_3), IC2.39 (GND_4), IC2.40 (GND_5), IC2.41 (GND_6), IC2.42 (GND_7), IC2.43 (GND_8), IC2.44 (GND_9), IC2.45 (GND_10), IC2.46 (GND_11), IC2.47 (GND_12), IC3.1 (GND), J1.2, J1.3, J2.2, J2.3, J5.16, J6.4, J7.3 (GND), J7.5 (GND), J7.9 (GNDDetect), JP1.1 (A), R4.1, R6.1, R8.2, R12.2, R14.2, R20.1, R21.2, R23.1, R29.2, R31.1, R32.1, R33.2, R35.2, R37.2, RV1.2, RV2.3, RV4.3, RV6.2, SW1.1, TP1.1, U1.1 (GND), U2.8 (GND), U3.8 (GND), U4.4 (V-), U5.4 (V-)
unnamed: D1.1 (A1), R10.1
unnamed: D1.2 (A2), R11.1
unnamed: C15.1, D2.2 (A2), F1.2, Q1.3 (D), RV1.1
unnamed: D3.2 (A), Q1.1 (G), R12.1
unnamed: D3.1 (K), Q1.2 (S), Q2.2 (S), Q3.2 (S), R13.1
unnamed: D4.1 (K), Q2.1 (G), R13.2
unnamed: C20.1, D5.2 (A2), F4.2, Q6.3 (D), RV6.1
unnamed: D6.2 (A), Q6.1 (G), R33.1
unnamed: D6.1 (K), Q6.2 (S), Q7.2 (S), Q8.2 (S), R34.1
unnamed: D7.1 (K), Q7.1 (G), R34.2
unnamed: F2.2, Q4.4 (D)
unnamed: F3.2, Q5.4 (D)
unnamed: C8.1, IC1.6 (CB)
unnamed: IC1.4 (FB), R7.2, R8.1
unnamed: C8.2, IC1.2 (SW), L1.1
unnamed: C22.1, IC3.6 (CB)
unnamed: IC3.4 (FB), R36.2, R37.1
unnamed: C22.2, IC3.2 (SW), L2.1
unnamed: Q2.3 (D), Q3.1 (G), R14.1
unnamed: Q4.1 (G), R19.1, R20.2
unnamed: Q4.3 (S), R17.1, R23.2
unnamed: Q5.1 (G), R28.2, R31.2
unnamed: Q5.3 (S), R27.1, R32.2
unnamed: Q7.3 (D), Q8.1 (G), R35.1
unnamed: R16.2, R18.1, U5.1
unnamed: R19.2, U4.1
unnamed: R25.2, R26.1, U5.7
unnamed: R28.1, U4.7
unnamed: R1.2, U2.6 (VREF)
unnamed: R2.2, U3.6 (VREF)
unnamed: R15.1, RV2.2, TP3.1, U4.3 (+)
unnamed: R17.2, U4.2 (-)
unnamed: R24.1, RV4.2, TP4.1, U4.5 (+)
unnamed: R27.2, U4.6 (-)
unnamed: R21.1, U5.3 (+)
unnamed: R29.1, U5.5 (+)

## KiCad design Hardware/LaserModule/laser_module_kicad_prj/laser_module_kicad_prj.kicad_pcb

Board: 2 copper layers, 100.0 x 70.0 mm, 110 parts (0 on the bottom side), 76 nets.

Parts:
C1, C2, C9, C10, C27, C28: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4, C5, C6, C8, C11, C12, C14, C15, C16, C17, C18, C20, C21, C23, C24, C26: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C25: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C13: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED_Dual_AAK; SOT-23
D2, D5: 35V; D_SMB
D3, D6: 3V; D_MiniMELF_Handsoldering
D4, D7: 5V6; D_MiniMELF_Handsoldering
F1: 500mA; Fuse_2512_6332Metric_Pad1.52x3.35mm_HandSolder
F2: 1A; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
F3, F4: 3A/5A; Fuse_2920_7451Metric_Pad2.10x5.45mm_HandSolder
IC1, IC3: LMR51420YFDDCR; SOT95P280X110-6N
IC2: ESP32-WROVER-IE; ESP32WROVERIE
J1, J2: Barrel_Jack_Switch_Pin3Ring; BarrelJack_Horizontal
J3: Conn_02x08_Odd_Even; IDC-Header_2x08_P2.54mm_Latch_Vertical
J4: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J5: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical_SMD
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
L1, L2: PCD0504
Q1, Q2, Q3, Q4, Q6, Q9: Si2307CDS; SOT-23_Handsoldering
Q5, Q7, Q8, Q10: Si2333DDS; SOT-23_Handsoldering
R1, R2, R3, R4, R8, R11, R12, R16, R17, R18, R19, R20, R23, R24, R25, R26, R27, R28, R29, R30, R33, R34, R37: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R31: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R32: 25k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9, R14, R15, R35, R36: 68; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 56; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21, R38: 0R1; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R22: 820; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV1, RV2: 30V; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm_H7.3mm
TP1: TP_GND; PinHeader_1x01_P2.54mm_Vertical
TP2, TP3, TP4, TP5: TestPoint; TestPoint_Pad_D1.5mm
U1: IFX27001TFV33; TO-252-3_TabPin2
U2, U3: ZXBM5210-S; SOIC-8_3.9x4.9mm_P1.27mm
U4, U5, U6, U7: OP07; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C2.1, C12.1, C13.1, C14.1, C16.1, C20.1, IC2.2 (3V3), J4.1, J5.1 (VTref), R8.2, U1.2 (Q), U5.7 (V+), U7.7 (V+)
+5V: C1.1, C15.1, C18.1, J3.15, Q7.3 (D), R3.2, R4.2, U1.3 (I), U4.7 (V+), U6.7 (V+)
/DC-DC Converter 1/Vin: C7.1, C25.1, IC1.3 (VIN), IC1.5 (EN), IC3.3 (VIN), IC3.5 (EN), Q10.3 (D)
/LASER1_CNTR: IC2.11 (IO26), R13.2
/LASER1_EN: IC2.9 (IO33), R12.2, R15.1
/LASER1_GND: J3.9, Q1.3 (D)
/LASER1_MD_MEAS: C17.1, IC2.6 (IO34), R11.1
/LASER1_TEMP: C5.1, IC2.24 (IO2), J3.11, R3.1
/LASER2_CNTR: IC2.10 (IO25), R22.2
/LASER2_EN: IC2.8 (IO32), R34.2, R36.1
/LASER2_GND: J3.10, Q3.3 (D)
/LASER2_MD_MEAS: C21.1, IC2.7 (IO35), R18.1
/LASER2_TEMP: C6.1, IC2.26 (IO4), J3.12, R4.1
/MONITORD1: J3.13, R17.2, U5.2 (-)
/MONITORD2: J3.14, R24.2, U7.2 (-)
/Mikrocontroller/BOOT: IC2.25 (IO0), JP1.2 (B)
/Mikrocontroller/ESP32_EN: C11.2, IC2.3 (EN), J5.10 (~RESET), R8.1, SW1.2
/Mikrocontroller/ESP32_JTAG_TCK: IC2.16 (IO13), J5.4 (SWDCLK/TCK)
/Mikrocontroller/ESP32_JTAG_TDI: IC2.14 (IO12), J5.8 (NC/TDI)
/Mikrocontroller/ESP32_JTAG_TDO: IC2.23 (IO15), J5.6 (SWO/TDO)
/Mikrocontroller/ESP32_JTAG_TMS: IC2.13 (IO14), J5.2 (SWDIO/TMS)
/Mikrocontroller/LED_GREEN: IC2.29 (IO5), R10.2
/Mikrocontroller/LED_RED: IC2.30 (IO18), R9.2
/Mikrocontroller/SERIAL_RX: IC2.34 (RXD0), J4.2
/Mikrocontroller/SERIAL_TX: IC2.35 (TXD0), J4.3
/PELT1_FWD: IC2.33 (IO21), U2.4 (FWD)
/PELT1_REV: IC2.31 (IO19), U2.5 (REV)
/PELT2_FWD: IC2.37 (IO23), U3.4 (FWD)
/PELT2_REV: IC2.36 (IO22), U3.5 (REV)
/PELTIER1+: J3.1, J3.3, U2.1 (OUT1)
/PELTIER1-: J3.5, J3.7, U2.7 (OUT2)
/PELTIER2+: J3.2, J3.4, U3.1 (OUT1)
/PELTIER2-: J3.6, J3.8, U3.7 (OUT2)
/Power Supply Protection 1/PWR_IN: F3.1, J1.1
/Power Supply Protection 2/PWR_IN: F4.1, J2.1
/Vpelt1: C3.1, C9.1, C10.1, L1.2, R1.1, R6.1, TP2.1, U2.2 (VM), U2.3 (VDD)
/Vpelt2: C4.1, C27.1, C28.1, L2.2, R2.1, R31.1, TP5.1, U3.2 (VM), U3.3 (VDD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C23.2, C24.2, C25.2, C27.2, C28.2, D1.3 (K), D2.1 (A1), D4.2 (A), D5.1 (A1), D7.2 (A), F1.2, F2.2, IC1.1 (GND), IC2.1 (GND_1), IC2.15 (GND_2), IC2.38 (GND_3), IC2.39 (GND_4), IC2.40 (GND_5), IC2.41 (GND_6), IC2.42 (GND_7), IC2.43 (GND_8), IC2.44 (GND_9), IC2.45 (GND_10), IC2.46 (GND_11), IC2.47 (GND_12), IC3.1 (GND), J1.2, J1.3, J2.2, J2.3, J3.16, J4.4, J5.3 (GND), J5.5 (GND), J5.9 (GNDDetect), JP1.1 (A), R7.2, R12.1, R16.2, R19.1, R20.1, R23.2, R25.2, R27.2, R28.2, R30.2, R32.2, R33.1, R34.1, R37.1, RV1.2, RV2.2, SW1.1, TP1.1, U1.1 (GND), U2.8 (GND), U3.8 (GND), U4.4 (V-), U5.4 (V-), U6.4 (V-), U7.4 (V-)
unnamed: C8.1, IC1.6 (CB)
unnamed: C8.2, IC1.2 (SW), L1.1
unnamed: C23.1, D2.2 (A2), F3.2, Q5.3 (D), RV1.1
unnamed: C24.1, D5.2 (A2), F4.2, Q8.3 (D), RV2.1
unnamed: C26.1, IC3.6 (CB)
unnamed: C26.2, IC3.2 (SW), L2.1
unnamed: D1.1 (A1), R9.1
unnamed: D1.2 (A2), R10.1
unnamed: D3.1 (K), Q5.2 (S), Q6.2 (S), Q7.2 (S), R26.1
unnamed: D3.2 (A), Q5.1 (G), R25.1
unnamed: D4.1 (K), Q6.1 (G), R26.2
unnamed: D6.1 (K), Q8.2 (S), Q9.2 (S), Q10.2 (S), R29.1
unnamed: D6.2 (A), Q8.1 (G), R28.1
unnamed: D7.1 (K), Q9.1 (G), R29.2
unnamed: F1.1, Q2.2 (S)
unnamed: F2.1, Q4.2 (S)
unnamed: IC1.4 (FB), R6.2, R7.1
unnamed: IC3.4 (FB), R31.2, R32.1
unnamed: Q1.1 (G), R14.1, R20.2
unnamed: Q1.2 (S), R21.2, U4.2 (-)
unnamed: Q2.1 (G), R15.2
unnamed: Q2.3 (D), R21.1
unnamed: Q3.1 (G), R35.2, R37.2
unnamed: Q3.2 (S), R38.2, U6.2 (-)
unnamed: Q4.1 (G), R36.2
unnamed: Q4.3 (D), R38.1
unnamed: Q6.3 (D), Q7.1 (G), R27.1
unnamed: Q9.3 (D), Q10.1 (G), R30.1
unnamed: R1.2, U2.6 (VREF)
unnamed: R2.2, U3.6 (VREF)
unnamed: R11.2, R17.1, U5.6
unnamed: R13.1, R19.2, TP3.1, U4.3 (+)
unnamed: R14.2, U4.6
unnamed: R16.1, U5.3 (+)
unnamed: R18.2, R24.1, U7.6
unnamed: R22.1, R33.2, TP4.1, U6.3 (+)
unnamed: R23.1, U7.3 (+)
unnamed: R35.1, U6.6
